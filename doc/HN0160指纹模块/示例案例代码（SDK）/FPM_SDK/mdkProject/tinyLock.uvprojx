# Keil uVision project tinyLock.uvprojx, settings and files
target tinyLock (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HC32L110C4UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tinyLock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\application;..\board;..\common;..\driver\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group application
    ../application/: fp.c fpmComm.c example.c hzDevice.c auth.c md5.c
  group board
    ../board/: hzDelay.c hzGpio.c hzInterrupt.c hzMisc.c hzUart.c hzAdc.c
  group common
    ../common/: system_hc32l110.c startup_hc32l110.s
  group driver
    ../driver/src/: clk.c ddl.c gpio.c adc.c adt.c bt.c crc.c flash.c i2c.c lpm.c lpt.c lpuart.c lvd.c pca.c reset.c rtc.c spi.c trim.c uart.c vc.c wdt.c interrupts_hc32l110.c
software components: CMSIS:CORE 5.0.1
